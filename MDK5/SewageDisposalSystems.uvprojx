# Keil uVision project SewageDisposalSystems.uvprojx, settings and files
target china_std (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Stm32_CJ01 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: CHINA_STD=1,USE_STDPERIPH_DRIVER,STM32F40_41xxx,STM32F4XX,__DEBUG_FLASH=0,_TEST_FLASH=0,_TEST_FLASH_2=0,__CC_ARM
  c misc: --c99 --diag_suppress=161
  c include: ..\sourcecode\app\;..\sourcecode\module\;..\sourcecode\module\mod_time;..\sourcecode\module\utility;..\sourcecode\module\FATFS\exfuns;..\sourcecode\module\mod_malloc;..\sourcecode\BSP\;..\sourcecode\BSP\fatfs;..\sourcecode\BSP\STM32F4xx_StdPeriph_Driver;..\sourcecode\BSP\STM32F4xx_StdPeriph_Driver\inc;..\sourcecode\UCOSII\CONFIG;..\sourcecode\UCOSII\CORE;..\sourcecode\UCOSII\PORT;..\sourcecode;..\sourcecode\module\debug_log;..\sourcecode\LWIP\lwip-1.4.1\src\include\netif;..\sourcecode\LWIP\lwip-1.4.1\src\include\lwip;..\sourcecode\LWIP\lwip-1.4.1\src\include\ipv4;..\sourcecode\LWIP\lwip-1.4.1\src\include;..\sourcecode\LWIP\app\TCP_Client;..\sourcecode\LWIP\lwip_header;..\sourcecode\LWIP\arch;..\sourcecode\LWIP;..\sourcecode\public\queue;..\sourcecode\public\sys_config;..\sourcecode\public\utility;..\sourcecode\public\crc;..\sourcecode\public\sys_error_manage;..\sourcecode\FATFS\source;..\sourcecode\module\mod_log;..\sourcecode\app\modbus
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ../sourcecode/app/: main.c text.c pump.c a2o.c mbr.c sbr.c spi_uart.c sys_config.c
  group Module
    ../sourcecode/module/mod_time/: mod_time.c
    ../sourcecode/module/mod_malloc/: mod_malloc.c
    ../sourcecode/module/mod_log/: debug_log.c
    ../sourcecode/app/modbus/: modbus_register.c modbus_slave.c
    ../sourcecode/app/: chip_communication.c
  group BSP
    ../sourcecode/BSP/STM32F4xx_StdPeriph_Driver/: system_stm32f4xx.c stm32f4xx_it.c
    ../sourcecode/BSP/: sys_timer.c cj01_io_api.c cj01_wdt.c cj01_ps2key.c cj01_exti.c cj01_gpio.c cj01_mdb.c cj01_rtc.c cj01_usart.c cj01_timer.c cj01_internal_flash.c cj01_lan8720.c cj01_sram.c cj01_simulate_IIC.c
  group PROJECT
    ../sourcecode/: version.h includes.h
  group PUBLIC
    ../sourcecode/public/queue/: queue.c
    ../sourcecode/public/utility/: utility.c
    ../sourcecode/public/sys_config/: sys_config.h sys_config.c
    ../sourcecode/public/sys_error_manage/: system_error.c
    ../sourcecode/public/crc/: crc.c
  group OS
    ../sourcecode/UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group OS_PORT
    ../sourcecode/UCOSII/PORT/: os_cpu_c.c os_cpu_a.asm os_cpu.h
  group BSPLIB
    ./BSP_LIB/Output/: Stm32_CJ01.lib
    ../sourcecode/BSP/: startup_stm32f40_41xxx.s
    ../sourcecode/BSP/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4x7_eth.c
  group LWIP_NETIF
    ../sourcecode/LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group LWIP_CORE
    ../sourcecode/LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../sourcecode/LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c mem.c
  group LWIP_ARCH
    ../sourcecode/LWIP/arch/: sys_arch.c
  group LWIP_API
    ../sourcecode/LWIP/lwip-1.4.1/src/api/: api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c api_lib.c
  group FATFS
    ../sourcecode/FATFS/source/: ff.c ffunicode.c ffsystem.c diskio.c ff_gen_drv.c
  group BSP/FATFS
    ../sourcecode/BSP/fatfs/: bsp_driver_sd.c fatfs.c sd_diskio.c user_diskio.c W25Q128JV.c
target Debug (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Stm32_CJ01 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,__DEBUG_FLASH=0,_TEST_FLASH=0,_TEST_FLASH_2=0,__CC_ARM
  c misc: --c99 --diag_suppress=161
  c include: ..\sourcecode\app\;..\sourcecode\app\app_init;..\sourcecode\app\app_menu;..\sourcecode\app\app_print;..\sourcecode\app\ccpark_rate;..\sourcecode\app\CHINA_STD;..\sourcecode\app\app_system_error;..\sourcecode\module\;..\sourcecode\resource\res_OAM;..\sourcecode\module\extern_data;..\sourcecode\module\mod_crc_check;..\sourcecode\module\mod_bill_receive\mod_bill_receive_ba_08;..\sourcecode\module\mod_bill_change;..\sourcecode\module\mod_bill_change\mod_bill_change_cdm_4000;..\sourcecode\module\mod_coin_receive\mod_coin_receive_g13;..\sourcecode\module\mod_coin_change\mod_coin_change_ict_hopper;..\sourcecode\module\mod_bill_receive\mod_bill_receive_cash_code;..\sourcecode\module\mod_mdb\mod_nri_coin_change\source;..\sourcecode\module\mod_coin_circulator\mod_coin_circulator_C2_mdb;..\sourcecode\module\mod_credit_card;..\sourcecode\module\mod_crt_284;..\sourcecode\module\mod_gate;..\sourcecode\module\mod_ic_reader;..\sourcecode\module\mod_lcd;..\sourcecode\module\mod_menu;..\sourcecode\module\mod_printer;..\sourcecode\module\mod_Ps2_key;..\sourcecode\module\mod_reader;..\sourcecode\module\mod_scanner;..\sourcecode\module\mod_ticketin;..\sourcecode\module\OAM;..\sourcecode\public\queue;..\sourcecode\module\mod_time;..\sourcecode\module\mod_trade_log;..\sourcecode\module\utility;..\sourcecode\module\mod_mdb;..\sourcecode\module\FATFS\exfuns;..\sourcecode\module\mod_sdcard_log;..\sourcecode\module\mod_malloc;..\sourcecode\FATFS\source;..\sourcecode\FATFS\documents\res;..\sourcecode\easylogger\inc;..\sourcecode\BSP\;..\sourcecode\BSP\STM32F4xx_StdPeriph_Driver;..\sourcecode\BSP\STM32F4xx_StdPeriph_Driver\inc;..\sourcecode\UCOSII\CONFIG;..\sourcecode\UCOSII\CORE;..\sourcecode\UCOSII\PORT;..\sourcecode;..\sourcecode\resource;..\sourcecode\resource\res_card;..\sourcecode\resource\res_cash_pay;..\sourcecode\resource\res_coil_output;..\sourcecode\resource\res_input_device;..\sourcecode\resource\res_input_key;..\sourcecode\resource\res_lcd;..\sourcecode\resource\res_print;..\sourcecode\resource\res_sensor;..\sourcecode\resource\res_universal;..\sourcecode\resource\res_debug_log;..\sourcecode\BSP;..\sourcecode\resource\res_run_log;..\sourcecode\BSP\STM32F4x7_ETH_Driver\inc;..\sourcecode\LWIP\lwip-1.4.1\src\include\netif;..\sourcecode\LWIP\lwip-1.4.1\src\include\lwip;..\sourcecode\LWIP\lwip-1.4.1\src\include\ipv4;..\sourcecode\LWIP\lwip-1.4.1\src\include;..\sourcecode\LWIP\app\TCP_Client;..\sourcecode\LWIP\lwip_header;..\sourcecode\LWIP\arch;..\sourcecode\LWIP;..\sourcecode\app\APP_LWIP;..\sourcecode\resource\res_communication;..\sourcecode\resource\res_save_config;..\sourcecode\resource\res_network;..\sourcecode\resource\res_menu;C:\Keil_v5\ARM\ARMCC\include;..\sourcecode\app\app_display_text;..\sourcecode\public\sys_config;..\sourcecode\public\utility;..\sourcecode\public\pub_crc_check;..\sourcecode\module\mod_credit_card\mod_credit_card_pos_lup100
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target locomobi (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: as above
  output: Stm32_CJ01 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: LOCOMOBI=1,USE_STDPERIPH_DRIVER,STM32F40_41xxx,__DEBUG_FLASH=0,_TEST_FLASH=0,_TEST_FLASH_2=0,__CC_ARM
  c misc: --c99 --diag_suppress=161
  c include: ..\sourcecode\app\;..\sourcecode\app\app_init;..\sourcecode\app\app_menu;..\sourcecode\app\app_print;..\sourcecode\app\ccpark_rate;..\sourcecode\app\CHINA_STD;..\sourcecode\app\app_system_error;..\sourcecode\module\;..\sourcecode\resource\res_OAM;..\sourcecode\module\extern_data;..\sourcecode\module\mod_crc_check;..\sourcecode\module\mod_bill_receive\mod_bill_receive_ba_08;..\sourcecode\module\mod_bill_change;..\sourcecode\module\mod_bill_change\mod_bill_change_cdm_4000;..\sourcecode\module\mod_coin_receive\mod_coin_receive_g13;..\sourcecode\module\mod_coin_change\mod_coin_change_ict_hopper;..\sourcecode\module\mod_bill_receive\mod_bill_receive_cash_code;..\sourcecode\module\mod_mdb\mod_nri_coin_change\source;..\sourcecode\module\mod_coin_circulator\mod_coin_circulator_C2_mdb;..\sourcecode\module\mod_credit_card;..\sourcecode\module\mod_crt_284;..\sourcecode\module\mod_gate;..\sourcecode\module\mod_ic_reader;..\sourcecode\module\mod_lcd;..\sourcecode\module\mod_menu;..\sourcecode\module\mod_printer;..\sourcecode\module\mod_Ps2_key;..\sourcecode\module\mod_reader;..\sourcecode\module\mod_scanner;..\sourcecode\module\mod_ticketin;..\sourcecode\module\OAM;..\sourcecode\public\queue;..\sourcecode\module\mod_time;..\sourcecode\module\mod_trade_log;..\sourcecode\module\utility;..\sourcecode\module\mod_mdb;..\sourcecode\module\FATFS\exfuns;..\sourcecode\module\mod_sdcard_log;..\sourcecode\module\mod_malloc;..\sourcecode\FATFS\source;..\sourcecode\FATFS\documents\res;..\sourcecode\easylogger\inc;..\sourcecode\BSP\;..\sourcecode\BSP\STM32F4xx_StdPeriph_Driver;..\sourcecode\BSP\STM32F4xx_StdPeriph_Driver\inc;..\sourcecode\UCOSII\CONFIG;..\sourcecode\UCOSII\CORE;..\sourcecode\UCOSII\PORT;..\sourcecode;..\sourcecode\resource;..\sourcecode\resource\res_card;..\sourcecode\resource\res_cash_pay;..\sourcecode\resource\res_coil_output;..\sourcecode\resource\res_input_device;..\sourcecode\resource\res_input_key;..\sourcecode\resource\res_lcd;..\sourcecode\resource\res_print;..\sourcecode\resource\res_sensor;..\sourcecode\resource\res_universal;..\sourcecode\resource\res_debug_log;..\sourcecode\BSP;..\sourcecode\resource\res_run_log;..\sourcecode\BSP\STM32F4x7_ETH_Driver\inc;..\sourcecode\LWIP\lwip-1.4.1\src\include\netif;..\sourcecode\LWIP\lwip-1.4.1\src\include\lwip;..\sourcecode\LWIP\lwip-1.4.1\src\include\ipv4;..\sourcecode\LWIP\lwip-1.4.1\src\include;..\sourcecode\LWIP\app\TCP_Client;..\sourcecode\LWIP\lwip_header;..\sourcecode\LWIP\arch;..\sourcecode\LWIP;..\sourcecode\app\APP_LWIP;..\sourcecode\resource\res_communication;..\sourcecode\resource\res_save_config;..\sourcecode\resource\res_network;..\sourcecode\resource\res_menu;C:\Keil_v5\ARM\ARMCC\include;..\sourcecode\app\app_display_text;..\sourcecode\public\sys_config;..\sourcecode\public\utility;..\sourcecode\public\pub_crc_check;..\sourcecode\module\mod_credit_card\mod_credit_card_pos_lup100;..\sourcecode\app\LOCOMOBI_APP\COMM;..\sourcecode\public\sys_error_manage;..\sourcecode\app\State_Machine
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target locomobi_temp (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: as above
  output: Stm32_CJ01 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: LOCOMOBI_NEW=1,USE_STDPERIPH_DRIVER,STM32F40_41xxx,__DEBUG_FLASH=0,_TEST_FLASH=0,_TEST_FLASH_2=0,__CC_ARM
  c misc: --c99 --diag_suppress=161
  c include: ..\sourcecode\app\;..\sourcecode\app\app_init;..\sourcecode\app\app_menu;..\sourcecode\app\app_print;..\sourcecode\app\ccpark_rate;..\sourcecode\app\CHINA_STD;..\sourcecode\app\app_system_error;..\sourcecode\module\;..\sourcecode\resource\res_OAM;..\sourcecode\module\extern_data;..\sourcecode\module\mod_crc_check;..\sourcecode\module\mod_bill_receive\mod_bill_receive_ba_08;..\sourcecode\module\mod_bill_change;..\sourcecode\module\mod_bill_change\mod_bill_change_cdm_4000;..\sourcecode\module\mod_coin_receive\mod_coin_receive_g13;..\sourcecode\module\mod_coin_change\mod_coin_change_ict_hopper;..\sourcecode\module\mod_bill_receive\mod_bill_receive_cash_code;..\sourcecode\module\mod_mdb\mod_nri_coin_change\source;..\sourcecode\module\mod_coin_circulator\mod_coin_circulator_C2_mdb;..\sourcecode\module\mod_credit_card;..\sourcecode\module\mod_crt_284;..\sourcecode\module\mod_gate;..\sourcecode\module\mod_ic_reader;..\sourcecode\module\mod_lcd;..\sourcecode\module\mod_menu;..\sourcecode\module\mod_printer;..\sourcecode\module\mod_Ps2_key;..\sourcecode\module\mod_reader;..\sourcecode\module\mod_scanner;..\sourcecode\module\mod_ticketin;..\sourcecode\module\OAM;..\sourcecode\public\queue;..\sourcecode\module\mod_time;..\sourcecode\module\mod_trade_log;..\sourcecode\module\utility;..\sourcecode\module\mod_mdb;..\sourcecode\module\FATFS\exfuns;..\sourcecode\module\mod_sdcard_log;..\sourcecode\module\mod_malloc;..\sourcecode\FATFS\source;..\sourcecode\FATFS\documents\res;..\sourcecode\easylogger\inc;..\sourcecode\BSP\;..\sourcecode\BSP\STM32F4xx_StdPeriph_Driver;..\sourcecode\BSP\STM32F4xx_StdPeriph_Driver\inc;..\sourcecode\UCOSII\CONFIG;..\sourcecode\UCOSII\CORE;..\sourcecode\UCOSII\PORT;..\sourcecode;..\sourcecode\resource;..\sourcecode\resource\res_card;..\sourcecode\resource\res_cash_pay;..\sourcecode\resource\res_coil_output;..\sourcecode\resource\res_input_device;..\sourcecode\resource\res_input_key;..\sourcecode\resource\res_lcd;..\sourcecode\resource\res_print;..\sourcecode\resource\res_sensor;..\sourcecode\resource\res_universal;..\sourcecode\resource\res_debug_log;..\sourcecode\BSP;..\sourcecode\resource\res_run_log;..\sourcecode\BSP\STM32F4x7_ETH_Driver\inc;..\sourcecode\LWIP\lwip-1.4.1\src\include\netif;..\sourcecode\LWIP\lwip-1.4.1\src\include\lwip;..\sourcecode\LWIP\lwip-1.4.1\src\include\ipv4;..\sourcecode\LWIP\lwip-1.4.1\src\include;..\sourcecode\LWIP\app\TCP_Client;..\sourcecode\LWIP\lwip_header;..\sourcecode\LWIP\arch;..\sourcecode\LWIP;..\sourcecode\app\APP_LWIP;..\sourcecode\resource\res_communication;..\sourcecode\resource\res_save_config;..\sourcecode\resource\res_network;..\sourcecode\resource\res_menu;C:\Keil_v5\ARM\ARMCC\include;..\sourcecode\app\app_display_text;..\sourcecode\public\sys_config;..\sourcecode\public\utility;..\sourcecode\public\pub_crc_check;..\sourcecode\module\mod_credit_card\mod_credit_card_pos_lup100;..\sourcecode\app\LOCOMOBI_APP\COMM;..\sourcecode\public\sys_error_manage;..\sourcecode\app\State_Machine;..\sourcecode\module\mod_tdg_xapt303
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
